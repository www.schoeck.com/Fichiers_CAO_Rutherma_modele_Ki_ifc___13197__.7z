Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T22:17:38
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki50-CV50-V8-H210-REI90
CADClick-Properties - Bestellnummer: 1029705; Beschreibung: Ki50-CV50-V8-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki50-CV50-V8-H210-REI90; EAN: 4024342535712; Name: Ki50-CV50-V8-H210-REI90
