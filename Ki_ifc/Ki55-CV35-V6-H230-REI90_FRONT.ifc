Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T00:54:40
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki55-CV35-V6-H230-REI90
CADClick-Properties - Bestellnummer: 1120124; Beschreibung: Ki55-CV35-V6-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki55-CV35-V6-H230-REI90; EAN: 4056327080566; Name: Ki55-CV35-V6-H230-REI90
