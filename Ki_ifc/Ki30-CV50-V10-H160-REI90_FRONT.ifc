Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T21:19:11
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki30-CV50-V10-H160-REI90
CADClick-Properties - Bestellnummer: 1029680; Beschreibung: Ki30-CV50-V10-H160-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki30-CV50-V10-H160-REI90; EAN: 4024342535460; Name: Ki30-CV50-V10-H160-REI90
