Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T00:41:23
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki55-CV35-V10-H190-REI90
CADClick-Properties - Bestellnummer: 1120110; Beschreibung: Ki55-CV35-V10-H190-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki55-CV35-V10-H190-REI90; EAN: 4056327080702; Name: Ki55-CV35-V10-H190-REI90
