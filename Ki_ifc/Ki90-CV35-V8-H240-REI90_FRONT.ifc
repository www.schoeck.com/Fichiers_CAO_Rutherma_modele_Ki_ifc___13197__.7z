Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T02:04:18
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki90-CV35-V8-H240-REI90
CADClick-Properties - Bestellnummer: 1120195; Beschreibung: Ki90-CV35-V8-H240-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki90-CV35-V8-H240-REI90; EAN: 4056327079850; Name: Ki90-CV35-V8-H240-REI90
