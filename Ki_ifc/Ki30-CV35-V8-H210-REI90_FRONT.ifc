Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T00:18:23
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki30-CV35-V8-H210-REI90
CADClick-Properties - Bestellnummer: 1120072; Beschreibung: Ki30-CV35-V8-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki30-CV35-V8-H210-REI90; EAN: 4056327081082; Name: Ki30-CV35-V8-H210-REI90
