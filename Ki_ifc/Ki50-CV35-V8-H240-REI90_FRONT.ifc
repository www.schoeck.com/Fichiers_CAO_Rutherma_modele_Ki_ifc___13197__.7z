Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T01:01:28
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki50-CV35-V8-H240-REI90
CADClick-Properties - Bestellnummer: 1120105; Beschreibung: Ki50-CV35-V8-H240-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki50-CV35-V8-H240-REI90; EAN: 4056327080757; Name: Ki50-CV35-V8-H240-REI90
