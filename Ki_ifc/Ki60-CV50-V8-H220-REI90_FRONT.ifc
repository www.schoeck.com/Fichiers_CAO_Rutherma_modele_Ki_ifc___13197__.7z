Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T23:06:05
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki60-CV50-V8-H220-REI90
CADClick-Properties - Bestellnummer: 1029766; Beschreibung: Ki60-CV50-V8-H220-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki60-CV50-V8-H220-REI90; EAN: 4024342536221; Name: Ki60-CV50-V8-H220-REI90
