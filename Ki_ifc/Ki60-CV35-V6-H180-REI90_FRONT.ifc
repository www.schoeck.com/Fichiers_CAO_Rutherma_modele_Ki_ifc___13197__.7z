Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T02:02:25
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki60-CV35-V6-H180-REI90
CADClick-Properties - Bestellnummer: 1120149; Beschreibung: Ki60-CV35-V6-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki60-CV35-V6-H180-REI90; EAN: 4056327080313; Name: Ki60-CV35-V6-H180-REI90
