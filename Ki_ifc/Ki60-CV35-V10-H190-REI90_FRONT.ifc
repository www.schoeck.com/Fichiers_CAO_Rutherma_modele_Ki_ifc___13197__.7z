Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T01:30:04
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki60-CV35-V10-H190-REI90
CADClick-Properties - Bestellnummer: 1120140; Beschreibung: Ki60-CV35-V10-H190-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki60-CV35-V10-H190-REI90; EAN: 4056327080405; Name: Ki60-CV35-V10-H190-REI90
