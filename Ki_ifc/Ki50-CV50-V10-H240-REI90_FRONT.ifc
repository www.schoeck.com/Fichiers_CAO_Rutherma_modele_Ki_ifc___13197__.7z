Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T22:38:23
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki50-CV50-V10-H240-REI90
CADClick-Properties - Bestellnummer: 1029718; Beschreibung: Ki50-CV50-V10-H240-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki50-CV50-V10-H240-REI90; EAN: 4024342535842; Name: Ki50-CV50-V10-H240-REI90
