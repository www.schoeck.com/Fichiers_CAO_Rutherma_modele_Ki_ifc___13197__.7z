Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T22:57:08
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki55-CV50-V10-H180-REI90
CADClick-Properties - Bestellnummer: 1029742; Beschreibung: Ki55-CV50-V10-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki55-CV50-V10-H180-REI90; EAN: 4024342536023; Name: Ki55-CV50-V10-H180-REI90
