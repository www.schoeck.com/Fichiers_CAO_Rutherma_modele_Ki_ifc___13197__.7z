Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T22:38:49
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki60-CV50-V10-H210-REI90
CADClick-Properties - Bestellnummer: 1029775; Beschreibung: Ki60-CV50-V10-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki60-CV50-V10-H210-REI90; EAN: 4024342536290; Name: Ki60-CV50-V10-H210-REI90
