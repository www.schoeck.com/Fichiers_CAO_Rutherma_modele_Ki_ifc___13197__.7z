Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T22:27:08
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki50-CV50-V8-H180-REI90
CADClick-Properties - Bestellnummer: 1029702; Beschreibung: Ki50-CV50-V8-H180-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki50-CV50-V8-H180-REI90; EAN: 4024342535682; Name: Ki50-CV50-V8-H180-REI90
