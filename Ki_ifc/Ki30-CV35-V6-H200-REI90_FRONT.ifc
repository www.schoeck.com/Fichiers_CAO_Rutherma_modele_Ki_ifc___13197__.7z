Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T23:45:42
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki30-CV35-V6-H200-REI90
CADClick-Properties - Bestellnummer: 1120061; Beschreibung: Ki30-CV35-V6-H200-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki30-CV35-V6-H200-REI90; EAN: 4056327081198; Name: Ki30-CV35-V6-H200-REI90
