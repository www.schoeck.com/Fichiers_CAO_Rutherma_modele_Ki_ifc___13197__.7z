Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T21:50:31
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki50-CV50-V6-H170-REI90
CADClick-Properties - Bestellnummer: 1029691; Beschreibung: Ki50-CV50-V6-H170-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki50-CV50-V6-H170-REI90; EAN: 4024342535576; Name: Ki50-CV50-V6-H170-REI90
