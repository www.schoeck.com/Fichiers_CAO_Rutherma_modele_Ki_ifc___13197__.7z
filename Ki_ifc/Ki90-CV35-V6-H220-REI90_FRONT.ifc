Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T02:45:26
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki90-CV35-V6-H220-REI90
CADClick-Properties - Bestellnummer: 1120183; Beschreibung: Ki90-CV35-V6-H220-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki90-CV35-V6-H220-REI90; EAN: 4056327079973; Name: Ki90-CV35-V6-H220-REI90
