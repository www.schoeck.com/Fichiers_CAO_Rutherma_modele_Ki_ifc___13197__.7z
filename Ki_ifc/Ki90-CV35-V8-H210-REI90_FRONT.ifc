Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T02:14:48
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki90-CV35-V8-H210-REI90
CADClick-Properties - Bestellnummer: 1120192; Beschreibung: Ki90-CV35-V8-H210-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki90-CV35-V8-H210-REI90; EAN: 4056327079881; Name: Ki90-CV35-V8-H210-REI90
