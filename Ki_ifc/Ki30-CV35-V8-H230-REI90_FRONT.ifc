Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-27T00:12:28
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki30-CV35-V8-H230-REI90
CADClick-Properties - Bestellnummer: 1120074; Beschreibung: Ki30-CV35-V8-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki30-CV35-V8-H230-REI90; EAN: 4056327081068; Name: Ki30-CV35-V8-H230-REI90
