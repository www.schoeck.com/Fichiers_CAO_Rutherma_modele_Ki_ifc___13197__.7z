Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition []
Time: 2015-09-26T23:41:34
Author: Schöck GmbH
Organization: Henryk Ludwig, Henryk Ludwig
Written by: IfcOpenShell 0.3.0-rc3
Made in: IfcOpenShell 0.3.0-rc3

# IfcBuildingElementProxy, Ki90-CV50-V10-H230-REI90
CADClick-Properties - Bestellnummer: 1029807; Beschreibung: Ki90-CV50-V10-H230-REI90; Hersteller: Schöck Bauteile GmbH; Datei: Ki90-CV50-V10-H230-REI90; EAN: 4024342536559; Name: Ki90-CV50-V10-H230-REI90
